# Keil uVision project BLE_Minimum.uvprojx, settings and files
target BLE_Minimum (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_Minimum +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER BLE_STACK_SLAVE_DLE_CONF CONFIG_HW_HSE_TUNE=32 CONFIG_HW_SMPS_10uH CONFIG_HW_LS_XTAL
  c include: ..\Inc;..\Inc\bsp;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\Drivers\Peripherals_Drivers\inc;..\Middlewares\ST\hal\Inc;..\Middlewares\ST\NVMDB\Inc;..\Middlewares\ST\Bluetooth_LE\inc;..\Middlewares\ST\BLE_Application\layers_inc;..\Middlewares\ST\NVMDB\Inc;..\Middlewares\ST\Bluetooth_LE\inc;..\Middlewares\ST\BLECNTR\Inc;..\Middlewares\ST\AESMGR\Inc;..\Middlewares\ST\PKAMGR\Inc;..\Middlewares\ST\RNGMGR\Inc;..\Middlewares\ST\cryptolib\inc;..\Middlewares\ST\cryptolib\inc\AES
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\BlueNRG_LP.sct
  group Application
    ../Src/: bluenrg_lp_it.c lp_uart.c BLE_main.c
  group BSP
    ../Src/bsp/: bsp_io.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../Drivers/Peripherals_Drivers/src/: rf_driver_hal_vtimer.c rf_driver_ll_flash.c rf_driver_ll_timer.c rf_driver_ll_pka_v7b.c rf_driver_ll_pwr.c rf_driver_ll_usart.c
  group Middlewares/AES
    ../Middlewares/ST/AESMGR/Src/: aes_manager_bluenrg_lp.c
  group Middlewares/BLE_Stack
    ../Middlewares/ST/Bluetooth_LE/src/: stack_user_cfg.c
    ../Middlewares/ST/Bluetooth_LE/library/: libbluenrg_lp_stack.a
  group Middlewares/BLECNTR
    ../Middlewares/ST/BLECNTR/Src/: ble_controller.c ble_controller_bluenrg_lp.c
  group Middlewares/Cryptolib
    ../Middlewares/ST/cryptolib/: aes_hw.c libcrypto.a
  group Middlewares/Hal
    ../Middlewares/ST/hal/Src/: blue_unit_conversion.s context_switch.s fifo.c hal_miscutil.c miscutil.c osal.c osal_memcpy.s
  group Middlewares/NVM
    ../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/PKA
    ../Middlewares/ST/PKAMGR/Src/: pka_manager.c pka_manager_bluenrg_lp.c
  group Middlewares/RNG
    ../Middlewares/ST/RNGMGR/Src/: rng_manager.c rng_manager_bluenrg_lp.c
